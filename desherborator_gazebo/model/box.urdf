Commit message: Task 4.5 : Regulation algorithm (Final)

File: desherborator_gazebo/model/box.urdf (robot description, URDF)
Before this commit: robot simple_box, 1 links, 0 joints
Links:
- link my_box: geometry visual box size=0.2 0.2 0.5
